# Keil uVision project ChipVerification.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: FT32F030CBATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ChipVerification +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c include: ..\User\inc;..\utils\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group User
    ../User/src/: main.c
  group utils
    ../utils/src/: aes.c
software components: CMSIS:CORE 5.6.0, Device:FT32Driver:COMMON 1.0.1, Device:FT32Driver:FLASH 1.0.1, Device:FT32Driver:GPIO 1.0.1, Device:FT32Driver:RCC 1.0.1, Device:Startup 1.0.1
